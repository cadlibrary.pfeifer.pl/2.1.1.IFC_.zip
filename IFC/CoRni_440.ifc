Properties of the parts of a building model (IFC4)

# File
Description: no view
File name: CoRni_440.ifc
Time: 2024-10-29T09:37:15
Author: Aleksander Skuła
Organization: No Organization
Written by: ODA SDAI 24.5
Authorization: askula

# IfcBuildingStorey, CoRni
In: PCC_EXPORT
Elevation: 0 m

# IfcBuildingElementProxy, CoRni_440
In: CoRni
Material: S355J2+N
AllplanAttributes - Poziom_Dolny: 0 m; Poziom_Górny: 0 m; Typ_robót: Roboty betonowe; V6: 0 m; V7: 0 m; V8: 0 m; V9: 0; Nazwa obiektu: COLMSHOE_PFEIFER_CoRni_440; Nazwa: CoRni_440; Materiał: S355J2+N; CATALOG: https://pfeifer.pl/wp-content/uploads/2024/10/COLMSHOE_katalog-techniczny.pdf; MAX_CAPACITY: 440kN; WEBSITE: https://pfeifer.pl/podpory-slupowe-colmshoe/; Marka: PFEIFER; Zestaw atrybutów obiektu: Body; ID_komponentu_Allright: 0412PEb0000000036; Rodzaj rozliczenia: Szt
